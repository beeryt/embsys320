# IAR project MP3Player.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32L475xx; DEBUG; disabledPRINT_CPU_AVERAGE; IAR_COMPILER
  ICCARM.CCDiagSuppress: Pe2464, Ms014
  ICCARM.CCIncludePath2: Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; PJDF; MP3data; App\uCOS; Micrium\Software\uCOS-II\Source; Micrium\Software\uCOS-II\ARM-Cortex-M4\IAR; Adafruit\Adafruit-GFX; Adafruit\Adafruit_FT6206; Adafruit\Adafruit_ILI9341; Arduino\SD\src; App\libui\include; App\libui\mp3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: MP3Player.sim
  ILINK.IlinkOutputFile: MP3Player.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; NDEBUG
  ICCARM.CCIncludePath2: Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; PJDF; MP3data; App\uCOS; Micrium\Software\uCOS-II\Source; Micrium\Software\uCOS-II\ARM-Cortex-M4\IAR; Adafruit\Adafruit-GFX; Adafruit\Adafruit_FT6206; Adafruit\Adafruit_ILI9341; Arduino\SD\src; Arduino\SD\src\utility
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: MP3Player.srec
  group Adafruit/Adafruit-GFX
    Adafruit/Adafruit-GFX/: Adafruit_GFX.cpp Adafruit_GFX.h glcdfont.c library.properties license.txt README.txt
  group Adafruit/Adafruit_FT6206
    Adafruit/Adafruit_FT6206/: Adafruit_FT6206.cpp Adafruit_FT6206.h library.properties README.txt
  group Adafruit/Adafruit_ILI9341
    Adafruit/Adafruit_ILI9341/: Adafruit_ILI9341.cpp Adafruit_ILI9341.h library.properties README.txt
  group App
    App/: drivers.c drivers.h main.c mp3Util.c mp3Util.h shell.c task.h tasks.c
  group App/libui/include
    App/libui/include/: basebutton.h bitmap.h button.h canvas.h color.h duration.h event.h marquee.h node.h playback.h progressbar.h rect.h sprite.h text.h texturebutton.h vec2.h vec2.hpp
  group App/libui/src
    App/libui/src/: basebutton.cpp bitmap.cpp button.cpp canvas.cpp duration.cpp marquee.cpp node.cpp playback.cpp progressbar.cpp sprite.cpp text.cpp texturebutton.cpp
  group App/mp3
    App/libui/mp3/: mp3.cpp mp3.h song.cpp song.h util.h
  group App/uCOS
    App/uCOS/: app_cfg.h app_hooks.c os_cfg.h
  group Arduino/SD/src
    Arduino/SD/src/: File.cpp README.txt SD.cpp SD.h
  group Arduino/SD/src/utility
    Arduino/SD/src/utility/: FatStructs.h Sd2Card.cpp Sd2Card.h SdFat.h SdFatmainpage.h SdFatUtil.h SdFile.cpp SdInfo.h SdVolume.cpp
  group BSP
    BSP/: bsp.h bspI2c.c bspI2c.h bspLcd.c bspLcd.h bspMp3.c bspMp3.h bspSD.c bspSD.h bspSpi.c bspSpi.h bspUart.c bspUart.h datainit.c hw_init.c hw_init.h layout.icf nucleoboard.h startup.s
  group BSP/CMSIS
    BSP/CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h stm32l475xx.h stm32l4xx.h system_stm32l4xx.c system_stm32l4xx.h xcore_cmFunc.h xcore_cmInstr.h xcore_cmSimd.h
  group BSP/ST/StdPeripheralDrivers
    BSP/ST/StdPeripheralDrivers/: stm32f4xx_conf.h stm32l4xx_ll_bus.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_spi.c stm32l4xx_ll_spi.h stm32l4xx_ll_system.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h
  group Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR
    Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Micrium/Software/uCOS-II/Source
    Micrium/Software/uCOS-II/Source/: os_cfg_r.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c ucos_ii.h
  group MP3data
    MP3data/: GenerateMp3Header.ps1 train_crossing.h train_crossing.mp3
  group PJDF
    PJDF/: pjdf.c pjdf.h pjdfCtrlI2C.h pjdfCtrlLcdILI9341.h pjdfCtrlMp3VS1053.h pjdfCtrlSDAdafruit.h pjdfCtrlSpi.h pjdfInternal.h pjdfInternalI2C.c pjdfInternalLcdILI9341.c pjdfInternalMp3VS1053.c pjdfInternalSDAdafruit.c pjdfInternalSPI.c
  group Util
    Util/: print.c print.h printf.c printf.h util.h
